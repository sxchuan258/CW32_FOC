# Keil uVision project L010-MOTOR.uvprojx, settings and files
target l010-motor (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CW32L010F8 WHXY
  pack: WHXY.CW32L010_DFP.1.0.2
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: CW32L010_MOTOR +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Driver\Libraries\inc;.\User;.\MOTOR;.\Contol_Algorithm;.\BSW
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group STARTUP
    ./User/: startup_cw32l010.s
  group Driver
    ./Driver/Libraries/src/: cw32l010_adc.c cw32l010_atim.c cw32l010_btim.c cw32l010_crc.c cw32l010_flash.c cw32l010_gpio.c cw32l010_gtim.c cw32l010_pwr.c cw32l010_sysctrl.c system_cw32l010.c
  group User
    ./User/: main.c interrupts_cw32l010.c init.c Flash_Opration.c
  group MOTOR
    ./MOTOR/: global.c MOTOR.C sensorlessP.c sensorless.c GF_SinCos.c GMC_Clark.c GMC_Park.c GMC_ParkInv.c GMC_SvmStd.c GMC_ElimDcBusRip.c Atan.c
  group Contol_Algorithm
    ./Contol_Algorithm/: Control.c Filter.c Observer.c
  group BSW
    ./BSW/: CurSen.c
software components: CMSIS:CORE 5.6.0
